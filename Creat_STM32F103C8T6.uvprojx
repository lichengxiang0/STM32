# Keil uVision project Creat_STM32F103C8T6.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Creat_STM32F103C8T6
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\FWLIB\inc;.\USER;.\SYSTEM\sys;.\SYSTEM\usart;.\SYSTEM\delay;.\PROCESS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ./FWLIB/src/: stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_gpio.c misc.c
  group SYSTEM
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/delay/: delay.c
  group PROCESS
    ./PROCESS/: process.c
